# Keil uVision project Belief exp2.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Belief exp2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\bsp\inc;..\core;..\driver\inc;..\library\std\inc;..\system\delay;..\system\sys;..\system\usart;..\user;..\library\freertos\include;..\library\freertos\portable\RVDS\ARM_CM4F;..\task\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group bsp
    ../bsp/src/: beep.c BSP_CAN.c BSP_DMA.c BSP_GPIO.c BSP_NVIC.c BSP_TIM.c BSP_UART.c key.c led.c
  group core
    ../core/: startup_stm32f427xx.s
  group library
    ../library/std/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../library/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../library/freertos/portable/MemMang/: heap_4.c
    ../library/freertos/portable/RVDS/ARM_CM4F/: port.c
  group system
    ../system/delay/: delay.c
    ../system/sys/: sys.c
  group user
    ../user/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group driver
    ../driver/src/: Driver_Angular.c Driver_Armour.c Driver_CAN.c Driver_DBUS.c Driver_PID.c MadgwickAHRS.c mpu6500_driver.c mpu6500_i2c.c mpu6500_interrupt.c Driver_Magic.c Driver_Chassis.c Driver_Motor.c
  group task
    ../task/src/: Task_Sys_Init.c Task_Debug.c Task_Function.c Task_HighFreq.c
