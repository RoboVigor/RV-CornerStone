# Keil uVision project windmill.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Belief exp2 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\core;..\bsp\inc;..\driver\inc;..\library\std\inc;..\user;..\library\atom\debug;..\library\freertos\portable\RVDS\ARM_CM4F;..\user\common;..\library\atom\delay;..\library\atom\sys;..\library\atom\usart;..\library\atom\debug;..\library\mpu6500;..\library\vegmath;..\user\windmill;..\library\oled;..\library\ist8310;..\library\bmi088;..\library\debug;..\library\freertos\include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group core
    ../core/: startup_stm32f427xx.s
  group library
    ../library/std/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c stm32f4xx_i2c.c
    ../library/freertos/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../library/freertos/portable/MemMang/: heap_4.c
    ../library/freertos/portable/RVDS/ARM_CM4F/: port.c
    ../library/atom/delay/: delay.c
    ../library/atom/sys/: sys.c
    ../library/mpu6500/: MadgwickAHRS.c mpu6500_driver.c mpu6500_i2c.c
    ../library/atom/debug/: beep.c key.c led.c
    ../library/vegmath/: vegmath.c
    ../library/oled/: oled.c
  group driver
    ../driver/src/: Driver_CAN.c Driver_DBUS.c Driver_PID.c Driver_Magic.c Driver_Chassis.c Driver_Motor.c Driver_Filter.c Driver_Gyroscope.c Driver_BSP.c Driver_Protocol.c Driver_Fsm.c
    ../library/bmi088/: BMI088driver.c BMI088middleware.c
    ../library/ist8310/: ist8310driver.c ist8310middleware.c
  group user_common
    ../user/common/: macro.h system_stm32f4xx.c interrupt.h
  group user_windmill
    ../user/windmill/: bsp.c handle.c interrupt.c main.c task_debug.c tasks.c
